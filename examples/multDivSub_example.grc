options:
  parameters:
    author: josh
    generate_options: no_gui
    id: multDivSub_example
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_0
  id: analog_sig_source
  parameters:
    T: float
    ampl: '1.0'
    frequency: '1000'
    impl: cpu
    offset: '0'
    phase: '0'
    sampling_freq: samp_rate
    showports: 'False'
    waveform: analog.waveform_t.SIN
  states: {}
- name: analog_sig_source_0_0
  id: analog_sig_source
  parameters:
    T: float
    ampl: '17.0'
    frequency: '1000'
    impl: cpu
    offset: '0'
    phase: '0'
    sampling_freq: samp_rate
    showports: 'False'
    waveform: analog.waveform_t.CONSTANT
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    impl: cpu
    itemsize: '0'
    nports: '1'
    showports: 'False'
  states: {state: disabled}
- name: grcon22_multDivSelect_0
  id: grcon22_multDivSelect
  parameters:
    T: float
    impl: numpy
    select: 'True'
    showports: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from matplotlib import pyplot as plt
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      plt.plot(fg.snk.data())
      plt.show()
    section: main_after_stop
  states: {}
- name: snk
  id: blocks_vector_sink
  parameters:
    T: float
    impl: cpu
    reserve_items: '1024'
    showports: 'False'
    vlen: '1'
  states: {}
- name: streamops_head_0
  id: streamops_head
  parameters:
    impl: cpu
    itemsize: '0'
    nitems: '1000'
    showports: 'False'
  states: {}

connections:
- [analog_sig_source_0, '0', grcon22_multDivSelect_0, '0']
- [analog_sig_source_0_0, '0', grcon22_multDivSelect_0, '1']
- [grcon22_multDivSelect_0, '0', blocks_null_sink_0, '0']
- [grcon22_multDivSelect_0, '0', streamops_head_0, '0']
- [streamops_head_0, '0', snk, '0']

metadata:
  file_format: 1
